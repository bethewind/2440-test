# Keil uVision project demo_test.uvproj, settings and files
target demo_test (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: demo_test
  AfterMake: d:\Keil\ARM\BIN31\fromelf.exe --bin -o ./obj/demo_test.bin ./obj/demo_test.axf
  c flags: Optim=1
  c include: .\include;..\2440atest_rev04_0327
  memory RVCT1: ROM 0x0 size 0x800
  memory RVCT6: RAM 0x800 size 0x800
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: ..\common\RuninRAM.sct
  group startup
    ./: S3C2440A.s
  group Common Files
    ./: 2440lib.c 2440slib.s swis.s k9s1208_s.s
  group Source  Files
    ./: ac97.c Adcts.c am29f800.c camif.c camproset.c cpuspeed.c Dma.c dvstest.c Eint.c flash.c glib.c idle.c IIC.c iis.c iis_dual.c int.c iotest.c IrDA.c k9k2g16.c lcd.c lcdlib.c memtest.c mmu.c Nand.c nwait.c PD6710.c pll.c Power.c pwr_c.c retarget.c RTC.c sdi.c sleep.c Spi.c stone.c strata32.c swi.c Timer.c Uart0.c Uart1.c Uart2.c Uart_test.c user_test1.c user_test2.c user_test.c userlib.c xmain.c 2440test.cpp
  group readme
    ./: README.txt
